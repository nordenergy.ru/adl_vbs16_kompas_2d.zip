# KOMPAS-3D drawing (VBS16 勩10 愩16 3_8''.cdw)

Views: Вид 1
Texts:
  Klimkovich
  ADL
Dimensions and other numbers on the sheet: 13; 3/8"; 64; 4,3; 1:1; 1; 0,2