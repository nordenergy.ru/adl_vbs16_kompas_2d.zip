# KOMPAS-3D drawing (VBS16 勩25 愩16 1''.cdw)

Views: Вид 1
Texts:
  Klimkovich
  ADL
Dimensions and other numbers on the sheet: 24; 105; 9,5; 1:1; 1