# KOMPAS-3D drawing (VBS16 勩20 愩16 3_4''.cdw)

Views: Вид 1
Texts:
  Klimkovich
  ADL
Dimensions and other numbers on the sheet: 21; 92; 8; 3/4"; 1:1; 1; 0,7