# KOMPAS-3D drawing (VBS16 勩15 愩16 1_2''.cdw)

Views: Вид 1
Texts:
  Klimkovich
  ADL
Dimensions and other numbers on the sheet: 16,8; 81,3; 1/2"; 5,5; 1:1; 1; 0,5